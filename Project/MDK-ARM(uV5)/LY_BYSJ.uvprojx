# Keil uVision project LY_BYSJ.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,__RTX
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp\inc;..\..\User\bsp;..\..\User;..\..\RL-ARM\Config;..\..\RL-ARM\Driver;..\..\RL-ARM\RL-RTX\inc;..\..\RL-ARM\RL-RTX\portable;..\..\User\app;..\..\User\fonts;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\emWin\Config;..\..\emWin\STemWin_Addons;..\..\User\libapp;..\..\Libraries\STM32F10x_DSP_Lib\inc;..\..\User\mp3\pub;..\..\User\mp3\real;..\..\RL-ARM\RL-CAN;..\..\RL-ARM\RL-USB;..\..\RL-ARM\RL-USB\INC;..\..\User\modbus
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c includes.h Retarget.c RTX_Conf_CM.c
    ../../RL-ARM/Config/: File_Config.c
  group APPLIB
    ../../User/libapp/: app_user_lib.c app_audio_lib.c app_mp3_lib.c app_wav_lib.c app_si4704_lib.c app_recorder_lib.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_rtc.c bsp_dwt.c bsp_beep.c bsp_timer.c bsp_ext_io.c bsp_si4730.c bsp_user_lib.c bsp_wm8978.c bsp_uart_fifo.c bsp_i2c_gpio.c bsp_tim_pwm.c bsp_fmc_sdram.c bsp_eeprom_24xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_fmc.c stm32f4xx_dma2d.c stm32f4xx_ltdc.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_sai.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group RL-RTX/Source
    ../../RL-ARM/RL-RTX/src/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c rt_Memory.c rt_Semaphore.c
  group RL-RTX/Ports
    ../../RL-ARM/RL-RTX/portable/: HAL_CM4.c rt_HAL_CM.h SVC_Table.s
  group RL-FlashFS/Lib
    ../../RL-ARM/RL-FlashFS/: FS_CM3.lib
  group RL-FlashFS/Driver
    ../../RL-ARM/Driver/: SDIO_STM32F4xx.c SDIO_STM32F4xx.h
  group Modbus/Master
    ../../User/modbus/: modbus_host.c
  group GUI/Fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hz24.c hz32.c song16.c SimSun_13.c ra8875_asc_width.c
  group GUI/LCD_Driver
    ../../User/bsp/src/: param.c bsp_gt811.c bsp_tft_429.c bsp_tft_lcd.c bsp_touch.c bsp_ts_ft5x06.c TOUCH_STMPE811.c
  group GUI/GUI_X
    ../../emWin/GUI_X/: GUI_X_RTX.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
  group GUI/DEMO
    ../../emWin/emWinTask/: MainTask.c MainTask.h App_StatusDlg.c App_SysInfoDlg.c App_ComputerDlg.c App_ComputerChildDlg.c App_SysConfigDlg.c App_MusicDlg.c App_MusicChildListDlg.c App_MusicChildSetDlg.c App_VideoDlg.c App_VideoChildListDlg.c App_RecorderDlg.c App_RadioDlg.c App_FileBrowseDlg.c App_FileBrowseChildDlg.c App_PicBrowseDlg.c App_CalendarDlg.c App_CalendarChildDlg.c App_Calculator.c App_ModbusDlg.c App_ReservedDlg.c
  group GUI/ICON
    ../../emWin/ICON/: AppIcon.c ClockBkPic.c ClockIcon.c ManualSearch.c Microphone.c MusicNext.c MusicPause.c MusicPlay.c MusicPre.c MusicStop.c MusiList.c RadioSearch.c RecorderIcon.c Return.c Setting.c Speaker.c SpeakerMute.c VedioIcon.c QQlcon.c
  group GUI/JPEG
    ../../emWin/JPEG/: GUI_JPEG.c jcomapi.c jdapimin.c jdapistd.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdphuff.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jidctred.c jmemmgr.c jquant1.c jquant2.c jutils.c
  group GUI/BkPic
    ../../emWin/Picture/: BkPic.c mupic.c 3D.c Computer.c Settings.c Music.c Video.c Radio.c Reader.c Recorder.c ADC.c DAC.c Camera.c Clock.c GPRS.c GPS.c Net.c Picture.c Sensor.c Signal.c SysIcon.c USB.c WIFI.c Wireless.c Calculator.c
  group GUI/HanZi
    ../../emWin/HanZi/: GUI_Font12.c GUI_Font16.c GUI_Font24.c GUI_Font32.c GUICharPEx.c GUI_UC_EncodeNone.c
  group GUI/Lib
    ../../emWin/GUILib/: GUI_CM4F_L.lib
    ../../emWin/STemWin_Addons/: ST_GUI_Addons.h STemWin_Addons_KEIL.lib
  group DSP_FFT
    ../../Libraries/STM32F10x_DSP_Lib/inc/: table_fft.h stm32_dsp.h
    ../../Libraries/STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_64_stm32.s
  group MP3Decoder
    ../../User/mp3/: mp3dec.c mp3tabs.c
    ../../User/mp3/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../../User/mp3/real/arm/: asmmisc.s asmpoly_thumb2.s
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.例程操作说明.txt 0.4.自己做的相关笔记.txt 05.C语言笔记.txt
